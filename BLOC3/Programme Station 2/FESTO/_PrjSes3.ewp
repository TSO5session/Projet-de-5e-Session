# IAR project _PrjSes3.ewp, settings and files
configuration Debug (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\_generic\plain.i51
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl8051Normal.h
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCOptLevel: 1
  ICC8051.CCOptStrategy: 0
  ICC8051.IccLang: 1
  XLINK.XclFile: C:\Documents and Settings\Administrateur\Bureau\Prog\ProjetDepart\_Ver810_lnk51ew_DS89C450.xcl
configuration Release (8051)
  as the first configuration, except:
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\
  ICC8051.CCDefines: NDEBUG
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 1
  ICC8051.IccLang: 0
  XLINK.XclFile: lnk0t.xcl
configuration UPSD (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: UPSD3254A
  ICC8051.CCIncludePath2: J:\Projet_Session5_LNAH\S2_18Nov2014\Programme Station 2\FESTO\Libraire
  XLINK.XclFile: J:\Projet_Session5_LNAH\S1_11Nov2014\Bolide\IAR\_Ver810_lnk51ew_uPSD3254A.xcl
configuration DALLAS (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: DALLAS89C450
configuration UPSDDebug (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: UPSD3254A
  XLINK.XclFile: _Ver810_lnk51ew_uPSD3254A.xcl
configuration DALLASDebug (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: DALLAS89C450
  group (top)
    Libraire/: _Session3Main.cpp CLADDA.cpp CLCommunic.cpp CLDAC7554.cpp CLDelai.cpp CLEcran.cpp CLFesto.cpp CLHorloge.cpp CLHorloge1307.cpp CLHorlogeIO.cpp CLI2CBase.cpp CLI2CPort.cpp CLI2CReg.cpp CLInOutBase.cpp CLIOPcf8574.cpp CLMaison.cpp CLMCP2515.cpp CLPiece.cpp CLSPI.cpp CLTest.cpp CLTLV2544.cpp
