# IAR project _PrjSes3.ewp, settings and files
configuration Debug (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\_generic\plain.i51
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl8051Normal.h
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCOptLevel: 1
  ICC8051.CCOptStrategy: 0
  ICC8051.IccLang: 1
  XLINK.XclFile: C:\Documents and Settings\Administrateur\Bureau\Prog\ProjetDepart\_Ver810_lnk51ew_DS89C450.xcl
configuration Release (8051)
  as the first configuration, except:
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\
  ICC8051.CCDefines: NDEBUG
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 1
  ICC8051.IccLang: 0
  XLINK.XclFile: lnk0t.xcl
configuration UPSD (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: UPSD3254A
  XLINK.XclFile: J:\FORG18089511\Annee3\Session 5\ProguC\Laboratoire\LABI2C\TSO\_Ver810_lnk51ew_uPSD3254A.xcl
configuration DALLAS (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: DALLAS89C450
configuration UPSDDebug (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: UPSD3254A
  XLINK.XclFile: _Ver810_lnk51ew_uPSD3254A.xcl
configuration DALLASDebug (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: DALLAS89C450
  group (top)
    Libraire/: _DeclarationGenerale.h _Session3Main.cpp _Session3Main.h CLADDA.cpp CLADDA.h CLCommunic.cpp CLCommunic.h CLDAC7554.cpp CLDAC7554.h CLDelai.cpp CLDelai.h CLEcran.cpp CLEcran.h CLFesto.cpp CLFesto.h CLHorloge.cpp CLHorloge.h CLHorloge1307.cpp CLHorloge1307.h CLHorlogeIO.cpp CLHorlogeIO.h CLI2CBase.cpp CLI2CBase.h CLI2CPort.cpp CLI2CPort.h CLI2CReg.cpp CLI2CReg.h CLInOutBase.cpp CLInOutBase.h CLIOPcf8574.cpp CLIOPcf8574.h CLMaison.cpp CLMaison.h CLMCP2515.cpp CLMCP2515.h CLPiece.cpp CLPiece.h CLSPI.cpp CLSPI.h CLTest.cpp CLTest.h CLTLV2544.cpp CLTLV2544.h ConversionKeilToIAR.h ioDS89C450.h iouPSD3254A.h TypeCible.h
