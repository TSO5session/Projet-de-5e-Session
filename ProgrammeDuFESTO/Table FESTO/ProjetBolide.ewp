# IAR project ProjetBolide.ewp, settings and files
configuration Debug (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\_generic\plain.i51
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl8051Normal.h
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCOptLevel: 1
  ICC8051.CCOptStrategy: 0
  ICC8051.IccLang: 1
  XLINK.XclFile: $TOOLKIT_DIR$\config\lnk51ew.xcl
configuration DS89C450 (8051, debug)
  as the first configuration, except:
  ICC8051.CCIncludePath2: C:\Users\1240249\Desktop\LeBolide\_Header
  XLINK.XclFile: C:\Users\1240249\Desktop\LAB6_Hicham\IAR\_Ver810_lnk51ew_DS89C450.xcl
configuration UPSD3254A (8051, debug)
  as the first configuration, except:
  ICC8051.CCIncludePath2: C:\Users\1240249\Desktop\LeBolide\_Header
  XLINK.XclFile: C:\Users\1240249\Desktop\LeBolide\_Ver810_lnk51ew_uPSD3254A.xcl
  group (top)
    _Source/: CLADCMAX1236.cpp CLClavier.cpp CLDAC6574.cpp CLDAC7554.cpp CLEcran.cpp CLHorloge1307.cpp CLI2CBase.Cpp CLI2CPort.Cpp CLInOutBase.cpp CLIOPCF8574.cpp CLMCP23S09.cpp CLMCP2515.cpp CLPile.cpp CLRoue.cpp CLRS232.cpp CLSerialPortInterface.cpp CLSuiveurLigne.cpp CLTest.cpp CLTLV2544.cpp CLVehicule.cpp CLXBEE.cpp Laboratoire.cpp
    _Header/: CLClavier.h CLMCP2515.h
