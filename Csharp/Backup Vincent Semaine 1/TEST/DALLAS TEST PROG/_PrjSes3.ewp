# IAR project _PrjSes3.ewp, settings and files
configuration Debug (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\_generic\plain.i51
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl8051Normal.h
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCOptLevel: 1
  ICC8051.CCOptStrategy: 0
  ICC8051.IccLang: 1
  XLINK.XclFile: C:\Cloud\Projet Générique IAR\_Ver810_lnk51ew_DS89C450.xcl
configuration Release (8051)
  as the first configuration, except:
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\
  General.RTConfigPath: xxx.h
  ICC8051.CCDefines: NDEBUG
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 1
  ICC8051.IccLang: 0
  XLINK.XclFile: lnk0t.xcl
configuration UPSD (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: UPSD3254A
  XLINK.XclFile: C:\Synchro\Dropbox\Travaux\Automne 2014\Prog\Labo6\Programme\_Ver810_lnk51ew_uPSD3254A.xcl
configuration DALLAS (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: DALLAS89C450
  XLINK.XclFile: C:\Synchro\Dropbox\Travaux\Automne 2014\Prog\Labo6\Programme\_Ver810_lnk51ew_DS89C450.xcl
configuration UPSDDebug (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: UPSD3254A
  XLINK.XclFile: _Ver810_lnk51ew_uPSD3254A.xcl
configuration DALLASDebug (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: DALLAS89C450
  XLINK.XclFile: _Ver810_lnk51ew_DS89C450.xcl
  group (top)
    ./: CANBUS.cpp CLClavier.cpp CLCommunic.cpp CLCommunic.h CLEcran.cpp CLI2CBase.Cpp CLI2CPort.Cpp CLinOutBase.cpp CLSortieLatch.cpp CLSPI.cpp NomDuProjet.cpp Optik.cpp Timer0.cpp
