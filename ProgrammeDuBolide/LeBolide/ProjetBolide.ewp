# IAR project ProjetBolide.ewp, settings and files
configuration Debug (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\_generic\plain.i51
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl8051Normal.h
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCOptLevel: 1
  ICC8051.CCOptStrategy: 0
  ICC8051.IccLang: 1
  XLINK.XclFile: $TOOLKIT_DIR$\config\lnk51ew.xcl
configuration DS89C450 (8051, debug)
  as the first configuration, except:
  ICC8051.CCIncludePath2: C:\Synchro\Dropbox\Travaux\Automne 2014\ProjetSession5\ProgrammeDUBolide\LeBolide
  XLINK.XclFile: C:\Synchro\Dropbox\Travaux\Automne 2014\ProjetSession5\ProgrammeDUBolide\LeBolide\_Ver810_lnk51ew_DS89C450.xcl
configuration UPSD3254A (8051, debug)
  as the first configuration, except:
  ICC8051.CCIncludePath2: F:\Projet\IAR\Header
  XLINK.XclFile: C:\Synchro\Dropbox\Travaux\OLD\Hiver2014\Le Bolide\Programme\PROJET FINAL COMPILABLE\_Ver810_lnk51ew_DS89C450.xcl
  group (top)
    ./: CLADCMAX1236.cpp CLADCuPSD.cpp CLCapteurDistance.cpp CLClavier.cpp CLCommunicCom2.cpp CLDAC6574.cpp CLDAC7554.cpp CLEcran.cpp CLHorloge1307.Cpp CLI2CBase.Cpp CLI2CPort.Cpp CLInclinometre.cpp CLInOutBase.cpp CLIOPCF8574.cpp CLLimiteVitesse.cpp CLMCP23S09.cpp CLPile.cpp CLPWMuPSD.cpp CLRoue.cpp CLSerialPortInterface.cpp CLSuiveurLigne.cpp CLTest.cpp CLTLV2544.cpp CLVehicule.cpp ProjetBolide.cpp
